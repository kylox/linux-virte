## drivers/staging/epita/Kconfig
```kconfig
config EPITA_TEST
	tristate "Simple test module for EPITA classes"
	depends on STAGING
	help
	  Not much here...
```
